## base_external/Config.in
```kconfig
menu "Custom Packages"

source "$BR2_EXTERNAL_project_base_PATH/package/aesd-assignments/Config.in"

endmenu
```
